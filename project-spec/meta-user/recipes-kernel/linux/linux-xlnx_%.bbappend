SRC_URI += "file://user_2020-11-28-12-58-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

