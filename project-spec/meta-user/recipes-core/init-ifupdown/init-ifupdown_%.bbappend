# EDGE ZYNQ network settings (DHCP plus a fixed 192.168.2.99)
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
